<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc1111_usb_dongle.ewp</path>
  </project>
  <batchBuild/>
</workspace>


