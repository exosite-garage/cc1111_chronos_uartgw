# IAR project cc1111_usb_dongle.ewp, settings and files
configuration 915MHz - Limited IAR Kickstart (USA) (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1111.i51
  ICC8051.CCDefines: ISM_US; MCU_H=<ioCC1111.h>; chip=1111; RF_FREQUENCY=915000; MRFI_CC1111; NDEBUG
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: bm-br1\; HAL\include\; HAL\source\; wbsl\; usb\; usb\class_cdc\; usb\library\; usb\library\ccxx11; sync\; simpliciti\; simpliciti\Components\bsp; simpliciti\Components\bsp\drivers; simpliciti\Components\bsp\boards\RFUSB; simpliciti\Components\mrfi; simpliciti\Components\nwk; simpliciti\Components\nwk_applications
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: chip=1111
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1111.xcl
configuration 868MHz - Limited IAR Kickstart (Europe) (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ISM_EU; MCU_H=<ioCC1111.h>; chip=1111; RF_FREQUENCY=868000; MRFI_CC1111; NDEBUG
configuration 433MHz - Limited IAR Kickstart (Other regions) (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ISM_LF; MCU_H=<ioCC1111.h>; chip=1111; RF_FREQUENCY=433000; MRFI_CC1111; NDEBUG
configuration 915MHz - Unrestricted IAR Workbench (USA) (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: bm-br1\; HAL\include\; HAL\source\; wbsl\; usb\; usb\class_cdc\; usb\library\; usb\library\ccxx11; sync\; simpliciti\; simpliciti\Components\bsp; simpliciti\Components\bsp\drivers; simpliciti\Components\bsp\boards\RFUSB; simpliciti\Components\mrfi; simpliciti\Components\nwk; simpliciti\Components\nwk_applications; embedded_uart
configuration 868MHz - Unrestricted IAR Workbench (Europe) (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
configuration 433MHz - Unrestricted IAR Workbench (Other regions) (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  group (top)
    ./: BM_API.h change_record.txt flash.c main.c rftest.c timer1.c
    embedded_uart/: embedded_uart.h
  group BlueRobin
    bm-br1/: BlueRobin_TX_433MHz.r51 BlueRobin_TX_868MHz.r51 BlueRobin_TX_915MHz.r51 bm.h project.h
  group HAL/include
    HAL/include/: hal.h hal_defs.h hal_types.h
  group HAL/source
    HAL/source/: hal_int.c
  group SimpliciTI
    simpliciti/: CC1111 - Access Point - 433MHz.r51 CC1111 - Access Point - 868MHz.r51 CC1111 - Access Point - 915MHz.r51 simpliciti.h simpliciti_readme.txt
  group SimpliciTI/Applications
    simpliciti/Applications/: app_remap_led.h main_AP_BM.c
  group SimpliciTI/Components/bsp
    simpliciti/Components/bsp/: bsp.c bsp.h bsp_macros.h
  group SimpliciTI/Components/bsp/boards/RFUSB
    simpliciti/Components/bsp/boards/RFUSB/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
  group SimpliciTI/Components/bsp/boards/RFUSB/bsp_external
    simpliciti/Components/bsp/boards/RFUSB/bsp_external/: mrfi_board_defs.h
  group SimpliciTI/Components/bsp/drivers
    simpliciti/Components/bsp/drivers/: bsp_buttons.h bsp_leds.h
  group SimpliciTI/Components/bsp/drivers/code
    simpliciti/Components/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
  group SimpliciTI/Components/bsp/mcus
    simpliciti/Components/bsp/mcus/: bsp_8051_defs.h
  group SimpliciTI/Components/mrfi
    simpliciti/Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group SimpliciTI/Components/mrfi/radios/common
    simpliciti/Components/mrfi/radios/common/: mrfi_f1f2.c mrfi_f1f2.h
  group SimpliciTI/Components/mrfi/radios/family2
    simpliciti/Components/mrfi/radios/family2/: mrfi_radio.c
  group SimpliciTI/Components/mrfi/smartrf/CC1111
    simpliciti/Components/mrfi/smartrf/CC1111/: smartrf_CC1111.h
  group SimpliciTI/Components/nwk
    simpliciti/Components/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group SimpliciTI/Components/nwk_applications
    simpliciti/Components/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
  group SimpliciTI/Configuration
    simpliciti/Configuration/: smpl_nwk_config.dat
  group SimpliciTI/Configuration/Access Point
    simpliciti/Configuration/Access Point/: smpl_config.dat
  group USB/class_cdc
    usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h usb_uart.c usb_uart.h
  group USB/library
    usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
    usb/library/ccxx11/: usb_interrupt.c usb_suspend.c
  group WBSL
    wbsl/: ioCCxx10_bitdef.h wbsl.c wbsl.h
